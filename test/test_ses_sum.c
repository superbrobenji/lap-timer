/* test_ses_sum.c -- .sum assembly byte-contract (spec §12.5).
 *
 * logger.c's rebuild_sum() writes HDR + VENUE + accumulated LAP frames + accumulated DRAG_RUN
 * frames + [END] to the .sum file. Session A1 (docs/.../2026-09-20-plan-dram-reclaim.md, Task 1)
 * replaces its single 4 KB assemble-then-emit scratch buffer with sequential writes of the same
 * sections to the open fd -- the bytes on storage must be byte-identical.
 *
 * The app-layer logger component is not part of the host build (test/CMakeLists.txt links core
 * only), so this test locks the CONTRACT at the layer that produces the bytes: the real core ses
 * encoders plus the exact §12.5 section order. It proves (a) the single-buffer assembly equals a
 * frozen golden captured from pre-refactor code, and (b) streaming the identical sections one at a
 * time to a sequential sink -- exactly what the refactored rebuild_sum does -- yields the same
 * golden byte-for-byte. If either the encoders or the assembly order ever drift, this fails. */
#include "unity.h"
#include "core/ses.h"
#include <stdint.h>
#include <string.h>

void setUp(void) {}
void tearDown(void) {}

/* Frozen golden .sum bytes, captured from the pre-refactor single-buffer assembly (438 B:
 * 99 HDR + 41 VENUE + 213 lap_acc + 71 drag_acc + 14 END) with the fixtures built below. */
static const uint8_t k_golden_sum[] = {
0xa5,0x01,0x5e,0x01,0x00,0x53,0x30,0x30,0x30,0x34,0x32,0x5f,
0x30,0x30,0x37,0x01,0x00,0x34,0x12,0x02,0x00,0x76,0x31,0x2e,
0x32,0x2e,0x33,0x2d,0x61,0x62,0x63,0x64,0x65,0x66,0x30,0x00,
0x00,0x45,0x53,0x50,0x33,0x32,0x2d,0x4e,0x45,0x4f,0x36,0x4d,
0x2d,0x30,0x30,0x30,0x31,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x14,0x0a,0x00,0x20,0x99,0xf4,0x83,0x22,0x06,0x00,
0xe8,0x03,0xe9,0x03,0xea,0x03,0xeb,0x03,0xec,0x03,0xed,0x03,
0xee,0x03,0xef,0x03,0xf0,0x03,0xfb,0xff,0xfc,0xff,0xfd,0xff,
0x03,0xed,0x67,0xa5,0x0d,0x24,0x34,0x12,0x02,0x00,0x4b,0x79,
0x61,0x6c,0x61,0x6d,0x69,0x20,0x47,0x50,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x10,0x26,0x40,0x47,0x4e,0x55,
0x5c,0x63,0x6a,0x71,0x78,0x7f,0x86,0x8d,0x94,0x9b,0xa2,0xa9,
0xb0,0xb7,0xbe,0xc5,0xcc,0xd3,0xda,0xe1,0xe8,0xef,0xf6,0xfd,
0x04,0x0b,0x12,0x19,0x20,0x27,0x2e,0x35,0x3c,0x43,0x4a,0x51,
0x58,0x5f,0x66,0x6d,0x74,0x7b,0x82,0x89,0x90,0x97,0x9e,0xa5,
0xac,0xb3,0xba,0xc1,0xc8,0xcf,0xd6,0xdd,0xe4,0xeb,0xf2,0xf9,
0x00,0x07,0x0e,0x15,0x1c,0x23,0x2a,0x31,0x38,0x3f,0x46,0x4d,
0x54,0x5b,0x62,0x69,0x70,0x77,0x7e,0x85,0x8c,0x93,0x9a,0xa1,
0xa8,0xaf,0xb6,0xbd,0xc4,0xcb,0xd2,0xd9,0xe0,0xe7,0xee,0xf5,
0xfc,0x03,0x0a,0x11,0x18,0x1f,0x26,0x2d,0x34,0x3b,0x42,0x49,
0x50,0x57,0x5e,0x65,0x6c,0x73,0x7a,0x81,0x88,0x8f,0x96,0x9d,
0xa4,0xab,0xb2,0xb9,0xc0,0xc7,0xce,0xd5,0xdc,0xe3,0xea,0xf1,
0xf8,0xff,0x06,0x0d,0x14,0x1b,0x22,0x29,0x30,0x37,0x3e,0x45,
0x4c,0x53,0x5a,0x61,0x68,0x6f,0x76,0x7d,0x84,0x8b,0x92,0x99,
0xa0,0xa7,0xae,0xb5,0xbc,0xc3,0xca,0xd1,0xd8,0xdf,0xe6,0xed,
0xf4,0xfb,0x02,0x09,0x10,0x17,0x1e,0x25,0x2c,0x33,0x3a,0x41,
0x48,0x4f,0x56,0x5d,0x64,0x6b,0x72,0x79,0x80,0x87,0x8e,0x95,
0x9c,0xa3,0xaa,0xb1,0xb8,0xbf,0xc6,0xcd,0xd4,0xdb,0xe2,0xe9,
0xf0,0xf7,0xfe,0x05,0x0c,0x80,0x8b,0x96,0xa1,0xac,0xb7,0xc2,
0xcd,0xd8,0xe3,0xee,0xf9,0x04,0x0f,0x1a,0x25,0x30,0x3b,0x46,
0x51,0x5c,0x67,0x72,0x7d,0x88,0x93,0x9e,0xa9,0xb4,0xbf,0xca,
0xd5,0xe0,0xeb,0xf6,0x01,0x0c,0x17,0x22,0x2d,0x38,0x43,0x4e,
0x59,0x64,0x6f,0x7a,0x85,0x90,0x9b,0xa6,0xb1,0xbc,0xc7,0xd2,
0xdd,0xe8,0xf3,0xfe,0x09,0x14,0x1f,0x2a,0x35,0x40,0x4b,0x56,
0x61,0x6c,0x77,0x82,0xa5,0x7f,0x09,0x00,0x66,0x5c,0x18,0x84,
0x22,0x06,0x00,0x02,0xfb,0x80,
};

/* Build the representative session fixtures rebuild_sum would hold at .sum time. */
static void fill_hdr(ses_hdr_t *h)
{
    memset(h, 0, sizeof *h);
    strcpy(h->session_id, "S00042_007");
    h->mode = 1; h->variant = 0; h->venue_id = 0x1234; h->layout_id = 0x0002;
    strcpy(h->fw, "v1.2.3-abcdef0"); strcpy(h->hwid, "ESP32-NEO6M-0001");
    h->log_profile = 0; h->fused_hz = 20; h->gps_hz = 10; h->start_gps_us = 1726800000000000LL;
    for (int i = 0; i < 9; i++) h->r_e4[i] = (int16_t)(1000 + i);
    for (int i = 0; i < 3; i++) h->gbias[i] = (int16_t)(-5 + i);
    h->calib_flags = 0x03;
}

/* lap_acc / drag_acc are opaque pre-encoded frame blobs that rebuild_sum copies verbatim; their
 * deterministic content only needs to be reproduced identically by both assembly strategies. */
static void fill_accumulators(uint8_t *lap, size_t lap_n, uint8_t *drag, size_t drag_n)
{
    for (size_t i = 0; i < lap_n; i++)  lap[i]  = (uint8_t)(0x40 + i * 7);
    for (size_t i = 0; i < drag_n; i++) drag[i] = (uint8_t)(0x80 + i * 11);
}

#define LAP_N  213u
#define DRAG_N 71u

/* Reference: the original single-buffer assemble-then-emit path. */
static size_t assemble_single_buffer(uint8_t *buf, size_t cap)
{
    ses_hdr_t h; fill_hdr(&h);
    uint8_t lap[LAP_N], drag[DRAG_N]; fill_accumulators(lap, LAP_N, drag, DRAG_N);
    size_t off = 0; int n;
    n = ses_encode_hdr(&h, buf + off, cap - off);                     TEST_ASSERT_GREATER_THAN(0, n); off += (size_t)n;
    n = ses_encode_venue(h.venue_id, h.layout_id, "Kyalami GP", buf + off, cap - off); TEST_ASSERT_GREATER_THAN(0, n); off += (size_t)n;
    memcpy(buf + off, lap, LAP_N);  off += LAP_N;
    memcpy(buf + off, drag, DRAG_N); off += DRAG_N;
    n = ses_encode_end(1726800600000000LL, 2, buf + off, cap - off);  TEST_ASSERT_GREATER_THAN(0, n); off += (size_t)n;
    return off;
}

/* A sequential byte sink standing in for the open .sum fd (one append == one sto_write). */
typedef struct { uint8_t bytes[4096]; size_t len; } sink_t;
static void sink_write(sink_t *s, const uint8_t *p, size_t n)
{
    TEST_ASSERT_LESS_OR_EQUAL(sizeof s->bytes, s->len + n);
    memcpy(s->bytes + s->len, p, n); s->len += n;
}

/* The refactored path: encode each section into a small local frame (<= FRAME_TMP_CAP) and stream
 * it straight to the fd; stream the accumulators from their own storage. No 4 KB scratch. */
static void assemble_streamed(sink_t *s)
{
    ses_hdr_t h; fill_hdr(&h);
    uint8_t lap[LAP_N], drag[DRAG_N]; fill_accumulators(lap, LAP_N, drag, DRAG_N);
    uint8_t frame[256]; int n;
    n = ses_encode_hdr(&h, frame, sizeof frame);                      TEST_ASSERT_GREATER_THAN(0, n); sink_write(s, frame, (size_t)n);
    n = ses_encode_venue(h.venue_id, h.layout_id, "Kyalami GP", frame, sizeof frame); TEST_ASSERT_GREATER_THAN(0, n); sink_write(s, frame, (size_t)n);
    sink_write(s, lap, LAP_N);
    sink_write(s, drag, DRAG_N);
    n = ses_encode_end(1726800600000000LL, 2, frame, sizeof frame);   TEST_ASSERT_GREATER_THAN(0, n); sink_write(s, frame, (size_t)n);
}

static void test_single_buffer_assembly_matches_golden(void)
{
    uint8_t buf[4096];
    size_t off = assemble_single_buffer(buf, sizeof buf);
    TEST_ASSERT_EQUAL_size_t(sizeof k_golden_sum, off);
    TEST_ASSERT_EQUAL_UINT8_ARRAY(k_golden_sum, buf, off);
}

static void test_streamed_assembly_is_byte_identical_to_golden(void)
{
    sink_t s; s.len = 0;
    assemble_streamed(&s);
    TEST_ASSERT_EQUAL_size_t(sizeof k_golden_sum, s.len);
    TEST_ASSERT_EQUAL_UINT8_ARRAY(k_golden_sum, s.bytes, s.len);
}

int main(void)
{
    UNITY_BEGIN();
    RUN_TEST(test_single_buffer_assembly_matches_golden);
    RUN_TEST(test_streamed_assembly_is_byte_identical_to_golden);
    return UNITY_END();
}
